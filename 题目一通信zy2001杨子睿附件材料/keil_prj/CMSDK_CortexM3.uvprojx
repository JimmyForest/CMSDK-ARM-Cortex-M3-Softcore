# Keil uVision project CMSDK_CortexM3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSDK_CortexM3
  AfterMake: fromelf -cvf .\Objects\CMSDK_CortexM3.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\Objects\CMSDK_CortexM3.axf -o image.txt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Core;.\Peripheral;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ./Core/: core_cm3.h core_cmFunc.h core_cmInstr.h CortexM3.h handler.c main.c Retarget.c startup_CM3DS.s system.c system.h
  group Peripheral
    ./Peripheral/: gpio.h gpio.c uart.c uart.h
  group User
    ./Peripheral/: spi_gpio.h spi_gpio.c
    ./User/: led.h key.h key.c led.c
